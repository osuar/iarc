<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USART_example_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\USART_example_polled.ewp</path>
  </project>
  <batchBuild/>
</workspace>


